<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>cmsis_button_toggle_led</project>
        <configuration>debug</configuration>
      </member>
      <member>
        <project>cmsis_button_toggle_led</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>debug</name>
      <member>
        <project>cmsis_button_toggle_led</project>
        <configuration>debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>release</name>
      <member>
        <project>cmsis_button_toggle_led</project>
        <configuration>release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/cmsis_button_toggle_led.ewp</path>
  </project>
</workspace>
