# Keil uVision project mc_pmsm_enc.uvprojx, settings and files
target mc_pmsm_enc release (6130001::V6.13.1::.\ARMCLANG)
  device: MCXA153VLH NXP
  pack: NXP.MCXA153_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33")
  output: mc_pmsm_enc.out
  AfterMake: fromelf.exe --output "$Lmc_pmsm_enc.bin" --bincombined "#L"
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, MC_EXAMPLE, DRTCESL_PQ_OFF=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MCXA153VLH, PMSM_SNSLESS, PMSM_SNSLESS_ENC, MID_EN
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../../../devices/MCXA153/drivers;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MCXA153;../../../../../../devices/MCXA153/periph;../../../../../../devices/MCXA153/utilities/debug_console_lite;../../../../../../components/lists;../../../../../../devices/MCXA153/utilities/str;../../../../../../components/uart;../../../../../../middleware/freemaster/src/common;../../../../../../middleware/freemaster/src/platforms/gen32le;../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can;../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial;../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.8_KEIL/AMCLIB/Include;../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.8_KEIL/GDFLIB/Include;../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.8_KEIL/GFLIB/Include;../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.8_KEIL/GMCLIB/Include;../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.8_KEIL/MLIB/Include;../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_algorithms;../../../../../../middleware/motor_control/pmsm/pmsm_frac/state_machine;../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_state_machine;../../../../../../middleware/motor_control/freemaster;../../../../../../middleware/motor_control/docs;../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_identification;../../../../../../middleware/motor_control/pmsm/pmsm_frac;../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_drivers;../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_algorithms/mcaa_lib/cm33nodsp_mdk/Include
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL, MCUXPRESSO_SDK, CPU_MCXA153VLH
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT6: RAM 0x4000000 size 0x2000
  memory RVCT7: RAM 0x14000000 size 0x2000
  memory RVCT8: RAM 0x4002000 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MCXA153_flash.scf
  link misc: ../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.8_KEIL/AMCLIB/AMCLIB.lib ../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.8_KEIL/GFLIB/GFLIB.lib ../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.8_KEIL/GDFLIB/GDFLIB.lib ../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.8_KEIL/GMCLIB/GMCLIB.lib ../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.8_KEIL/MLIB/MLIB.lib ../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_algorithms/mcaa_lib/cm33nodsp_mdk/mcaa_lib.lib --remove --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: main.c m1_pmsm_appconfig.h m2_pmsm_appconfig.h pin_mux.c pin_mux.h clock_config.c clock_config.h peripherals.c peripherals.h freemaster_cfg.h mc_periph_init.c mc_periph_init.h mcux_config.h
  group board
    ../: board.h board.c
  group drivers
    ../../../../../../devices/MCXA153/drivers/: fsl_clock.c fsl_clock.h fsl_inputmux_connections.h fsl_reset.c fsl_reset.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_eqdc.h fsl_eqdc.c fsl_gpio.h fsl_gpio.c fsl_inputmux.h fsl_inputmux.c fsl_lpadc.c fsl_lpadc.h fsl_lpcmp.c fsl_lpcmp.h fsl_lpuart.h fsl_lpuart.c fsl_spc.h fsl_spc.c fsl_port.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv8m_mpu.h
  group device
    ../../../../../../devices/MCXA153/: fsl_device_registers.h MCXA153.h MCXA153_features.h MCXA153_COMMON.h system_MCXA153.c system_MCXA153.h
  group device/periph
    ../../../../../../devices/MCXA153/periph/: PERI_ADC.h PERI_AOI.h PERI_CDOG.h PERI_CMC.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUGMAILBOX.h PERI_DMA.h PERI_EIM.h PERI_EQDC.h PERI_ERM.h PERI_FMC.h PERI_FMU.h PERI_FMUTEST.h PERI_FREQME.h PERI_GLIKEY.h PERI_GPIO.h PERI_I3C.h PERI_INPUTMUX.h PERI_LPCMP.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPTMR.h PERI_LPUART.h PERI_MRCC.h PERI_OSTIMER.h PERI_PORT.h PERI_PWM.h PERI_SCG.h PERI_SPC.h PERI_SYSCON.h PERI_TRDC.h PERI_USB.h PERI_UTICK.h PERI_VBAT.h PERI_WAKETIMER.h PERI_WUU.h PERI_WWDT.h
  group startup/arm
    ../../../../../../devices/MCXA153/arm/: startup_MCXA153.S
  group utilities
    ../../../../../../devices/MCXA153/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
    ../../../../../../devices/MCXA153/utilities/: fsl_memcpy.S
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group utilities/str
    ../../../../../../devices/MCXA153/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/MCXA153/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group freemaster/src/common
    ../../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_defcfg.h freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h freemaster_can.c freemaster_can.h freemaster_sha.c freemaster_pdbdm.c freemaster_serial.c freemaster_serial.h freemaster_net.c freemaster_net.h
  group freemaster/src/platforms/gen32le
    ../../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group freemaster/src/drivers/mcuxsdk/can
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mscan.c freemaster_mscan.h freemaster_mcan.c freemaster_mcan.h
  group freemaster/src/drivers/mcuxsdk/serial
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_usb.c freemaster_serial_usb.h
  group freemaster/src/drivers/mcuxsdk/network
    ../../../../../../middleware/freemaster/src/drivers/mcuxsdk/network/: freemaster_net_segger_rtt.c freemaster_net_segger_rtt.h freemaster_net_lwip_udp.c freemaster_net_lwip_udp.h freemaster_net_lwip_tcp.c freemaster_net_lwip_tcp.h
  group rtcesl/CM33NODSP_RTCESL_4.8_KEIL/AMCLIB/Include
    ../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.8_KEIL/AMCLIB/Include/: amclib.h AMCLIB_AngleTrackObsrv_F32.h AMCLIB_CtrlFluxWkng_A32.h AMCLIB_PMSMBemfObsrvAB_A32.h AMCLIB_PMSMBemfObsrvDQ_A32.h AMCLIB_TrackObsrv_F32.h amclib_types.h
  group rtcesl/CM33NODSP_RTCESL_4.8_KEIL/GDFLIB/Include
    ../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.8_KEIL/GDFLIB/Include/: gdflib.h GDFLIB_FilterExp_F32.h GDFLIB_FilterIIR1_F32.h GDFLIB_FilterIIR1_F32_Asmi.h GDFLIB_FilterIIR2_F32.h GDFLIB_FilterIIR3_F32.h GDFLIB_FilterIIR4_F32.h GDFLIB_FilterMA_A32.h gdflib_types.h
  group rtcesl/CM33NODSP_RTCESL_4.8_KEIL/GFLIB/Include
    ../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.8_KEIL/GFLIB/Include/: gflib.h GFLIB_Acos_F16.h GFLIB_Asin_F16.h GFLIB_Atan_F32.h GFLIB_AtanYX_F16.h GFLIB_AtanYXPQ_F16.h GFLIB_CtrlBetaIPDp_A32.h GFLIB_CtrlBetaIPp_A32.h GFLIB_CtrlPIDp_A32.h GFLIB_CtrlPIp_A32.h GFLIB_DFlexRamp_A32.h GFLIB_DRamp_F16.h GFLIB_DRamp_F32.h GFLIB_FlexRamp_A32.h GFLIB_FlexSRamp_A32.h GFLIB_Hyst_F16_Asmi.h GFLIB_Integrator_A32.h GFLIB_Limit_F16.h GFLIB_Limit_F32.h GFLIB_LowerLimit_F16.h GFLIB_LowerLimit_F32.h GFLIB_Lut_F16_Asmi.h GFLIB_Lut_F32.h GFLIB_LutPer_F16_Asmi.h GFLIB_LutPer_F32.h GFLIB_Ramp_F16.h GFLIB_Ramp_F32.h GFLIB_SinCos_F32.h GFLIB_SinCosPQ_F32.h GFLIB_Sqrt_F16.h GFLIB_Sqrt_F32.h GFLIB_SqrtPQ_F16.h GFLIB_SqrtPQ_F32.h GFLIB_Tan_F32.h gflib_types.h GFLIB_UpperLimit_F16.h GFLIB_UpperLimit_F32.h GFLIB_VectorLimit_F16.h
  group rtcesl/CM33NODSP_RTCESL_4.8_KEIL/GMCLIB/Include
    ../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.8_KEIL/GMCLIB/Include/: gmclib.h GMCLIB_Clark_F16_Asmi.h GMCLIB_Decoupling_A32.h GMCLIB_DTCompLut1D_F16.h GMCLIB_ElimDcBusRip_A32_Asmi.h GMCLIB_ElimDcBusRip_F16_Asmi.h GMCLIB_Park_F16_Asmi.h GMCLIB_Svm_F16.h gmclib_types.h
  group rtcesl/CM33NODSP_RTCESL_4.8_KEIL/MLIB/Include
    ../../../../../../middleware/rtcesl/CM33NODSP_RTCESL_4.8_KEIL/MLIB/Include/: asm_mac.h mlib.h MLIB_Abs_F16.h MLIB_Abs_F16_Asmi.h MLIB_Abs_F32.h MLIB_Abs_F32_Asmi.h MLIB_Add_A32.h MLIB_Add_A32_Asmi.h MLIB_Add_F16.h MLIB_Add_F16_Asmi.h MLIB_Add_F32.h MLIB_Add_F32_Asmi.h MLIB_Add4_F16_Asmi.h MLIB_Add4_F32_Asmi.h MLIB_BiShift_F16.h MLIB_BiShift_F32.h MLIB_Clb_F16.h MLIB_Clb_F32.h MLIB_Conv_F32.h MLIB_Div_A32.h MLIB_Div_F16.h MLIB_Div_F32.h MLIB_Div1Q_A32.h MLIB_Div1Q_F16.h MLIB_Div1Q_F32.h MLIB_Log2_U16.h MLIB_Mac_A32.h MLIB_Mac_F16.h MLIB_Mac_F16_Asmi.h MLIB_Mac_F32.h MLIB_Mac_F32_Asmi.h MLIB_Mac4_F32.h MLIB_Mac4Rnd_F16.h MLIB_Mac4Rnd_F16_Asmi.h MLIB_Mac4Rnd_F32.h MLIB_Mac4Rnd_F32_Asm.h MLIB_MacRnd_A32.h MLIB_MacRnd_F16.h MLIB_MacRnd_F16_Asmi.h MLIB_MacRnd_F32.h MLIB_MacRnd_F32_Asmi.h MLIB_Mnac_A32.h MLIB_Mnac_F16.h MLIB_Mnac_F16_Asmi.h MLIB_Mnac_F32.h MLIB_Mnac_F32_Asmi.h MLIB_MnacRnd_A32.h MLIB_MnacRnd_F16.h MLIB_MnacRnd_F16_Asmi.h MLIB_MnacRnd_F32.h MLIB_MnacRnd_F32_Asmi.h MLIB_Msu_A32.h MLIB_Msu_F16.h MLIB_Msu_F16_Asmi.h MLIB_Msu_F32.h MLIB_Msu_F32_Asmi.h MLIB_Msu4_F32.h MLIB_Msu4Rnd_F16.h MLIB_Msu4Rnd_F16_Asmi.h MLIB_Msu4Rnd_F32.h MLIB_Msu4Rnd_F32_Asm.h MLIB_MsuRnd_A32.h MLIB_MsuRnd_F16.h MLIB_MsuRnd_F16_Asmi.h MLIB_MsuRnd_F32.h MLIB_MsuRnd_F32_Asmi.h MLIB_Mul_A32.h MLIB_Mul_A32_Asmi.h MLIB_Mul_F16.h MLIB_Mul_F16_Asmi.h MLIB_Mul_F32.h MLIB_Mul_F32_Asmi.h MLIB_MulRnd_A32.h MLIB_MulRnd_A32_Asmi.h MLIB_MulRnd_F16.h MLIB_MulRnd_F16_Asmi.h MLIB_MulRnd_F32.h MLIB_MulRnd_F32_Asmi.h MLIB_Neg_F16.h MLIB_Neg_F16_Asmi.h MLIB_Neg_F32.h MLIB_Neg_F32_Asmi.h MLIB_PQ.h MLIB_Rcp_A32.h MLIB_Rcp1Q_A32.h MLIB_Rnd_F32.h MLIB_Rnd_F32_Asmi.h MLIB_Sat_A32_Asmi.h MLIB_Shift_F16.h MLIB_Shift_F16_Asmi.h MLIB_Shift_F32.h MLIB_Shift_F32_Asmi.h MLIB_Sign_F16_Asmi.h MLIB_Sign_F32_Asmi.h MLIB_Sub_A32.h MLIB_Sub_F16.h MLIB_Sub_F16_Asmi.h MLIB_Sub_F32.h MLIB_Sub_F32_Asmi.h MLIB_Sub_F64.h MLIB_Sub4_F16_Asmi.h MLIB_Sub4_F32_Asmi.h mlib_types.h RTCESL_cfg.h
  group motor_control/docs
    ../../../../../../middleware/motor_control/docs/: readme_pmsm.txt
  group motor_control/pmsm/pmsm_frac/mc_algorithms
    ../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_algorithms/: pmsm_control.c pmsm_control.h pmsm_control.c pmsm_control.h
  group motor_control/pmsm/pmsm_frac/state_machine
    ../../../../../../middleware/motor_control/pmsm/pmsm_frac/state_machine/: state_machine.c state_machine.h
  group motor_control/pmsm/pmsm_frac/mc_state_machine
    ../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_state_machine/: m1_sm_snsless_enc.c m1_sm_snsless_enc.h sm_common_enc.h
  group motor_control/freemaster
    ../../../../../../middleware/motor_control/freemaster/: pmsm_frac_enc.pmpx pmsm_frac_enc.pmpx
  group motor_control/pmsm/pmsm_frac/mc_identification
    ../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_identification/: mid_def.h mid_sm_states.c mid_sm_states.h pp_measure.c pp_measure.h m1_mid_switch.c m1_mid_switch.h
  group motor_control/pmsm/pmsm_frac
    ../../../../../../middleware/motor_control/pmsm/pmsm_frac/: fm_tsa_pmsm.c
  group motor_control/pmsm/pmsm_frac/mc_drivers
    ../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_drivers/: mcdrv_adc_mcxa.c mcdrv_adc_mcxa.h mcdrv_pwm3ph_epwm.c mcdrv_pwm3ph_epwm.h mcdrv_enc_eqd.c mcdrv_enc_eqd.h
  group motor_control/freemaster/pmsm_frac/mcat/assets
    ../../../../../../middleware/motor_control/freemaster/pmsm_frac/mcat/assets/: speedfocwolswbemf.gif
  group motor_control/freemaster/pmsm_frac/mcat/css
    ../../../../../../middleware/motor_control/freemaster/pmsm_frac/mcat/css/: app.css
  group motor_control/freemaster/pmsm_frac/mcat/js
    ../../../../../../middleware/motor_control/freemaster/pmsm_frac/mcat/js/: chunk.js chunk.js.map mcat.js mcat.js.map
  group motor_control/freemaster/pmsm_frac/mcat
    ../../../../../../middleware/motor_control/freemaster/pmsm_frac/mcat/: freemaster-client.js index.html init.js simple-jsonrpc-js.js
  group motor_control/pmsm/pmsm_frac/mc_algorithms/mcaa_lib/cm33nodsp_mdk/Include
    ../../../../../../middleware/motor_control/pmsm/pmsm_frac/mc_algorithms/mcaa_lib/cm33nodsp_mdk/Include/: MCAA_EstimRL.h mcaa_lib.h
  group doc
    ../: readme.md example_board_readme.md
