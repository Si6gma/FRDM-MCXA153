# IAR project fmstr_example_usb_cdc.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXA153 NXP MCXA153
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; USB_STACK_BM=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MCXA153VLH; OSA_USED; USE_RTOS=0
  ICCARM.IExtraOptions: --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../../devices/MCXA153/drivers; ../../../../../CMSIS/Core/Include; ../../../../../CMSIS/Core/Include/m-profile; ../../../../../devices/MCXA153; ../../../../../devices/MCXA153/periph; ../../../../../devices/MCXA153/utilities/debug_console_lite; ../../../../../components/lists; ../../../../../devices/MCXA153/utilities/str; ../../../../../components/uart; ../../../../../components/osa; ../../../../../middleware/usb/include; ../../../../../middleware/usb/device; ../../../../../middleware/usb/device/class; ../../../../../middleware/freemaster/src/common; ../../../../../middleware/freemaster/src/platforms/gen32le; ../../../../../middleware/freemaster/src/drivers/mcuxsdk/can; ../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MCXA153VLH; OSA_USED
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: fmstr_example_usb_cdc.out
  ILINK.IlinkConfigDefines: __heap_size__=0x1000; __stack_size__=0x800
  ILINK.IlinkIcfFile: MCXA153_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USB_STACK_BM=1; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MCXA153VLH; OSA_USED; USE_RTOS=0
  ICCARM.CCOptLevel: 3
  group source
    ../: main.c freemaster_cfg.h freemaster_example.h data_example_pmp.h data_html_index.h data_img_file.h data_img_fmstrlogo.h data_img_logo.h example_data.h freemaster_example.c freemaster_usb.h freemaster_usb.c freemaster_usb_device_descriptor.h freemaster_usb_device_descriptor.c usb_device_descriptor.h fsl_os_abstraction_config.h mcux_config.h usb_device_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h
  group drivers
    ../../../../../devices/MCXA153/drivers/: fsl_clock.c fsl_clock.h fsl_inputmux_connections.h fsl_reset.c fsl_reset.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_spc.h fsl_spc.c fsl_port.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group device
    ../../../../../devices/MCXA153/: fsl_device_registers.h MCXA153.h MCXA153_features.h MCXA153_COMMON.h system_MCXA153.c system_MCXA153.h
  group device/periph
    ../../../../../devices/MCXA153/periph/: PERI_ADC.h PERI_AOI.h PERI_CDOG.h PERI_CMC.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUGMAILBOX.h PERI_DMA.h PERI_EIM.h PERI_EQDC.h PERI_ERM.h PERI_FMC.h PERI_FMU.h PERI_FMUTEST.h PERI_FREQME.h PERI_GLIKEY.h PERI_GPIO.h PERI_I3C.h PERI_INPUTMUX.h PERI_LPCMP.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPTMR.h PERI_LPUART.h PERI_MRCC.h PERI_OSTIMER.h PERI_PORT.h PERI_PWM.h PERI_SCG.h PERI_SPC.h PERI_SYSCON.h PERI_TRDC.h PERI_USB.h PERI_UTICK.h PERI_VBAT.h PERI_WAKETIMER.h PERI_WUU.h PERI_WWDT.h
  group startup/iar
    ../../../../../devices/MCXA153/iar/: startup_MCXA153.s
  group utilities
    ../../../../../devices/MCXA153/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../devices/MCXA153/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../devices/MCXA153/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/osa
    ../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.h fsl_os_abstraction_bm.c
  group usb/include
    ../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group usb/device
    ../../../../../middleware/usb/device/: usb_device.h usb_device_khci.c usb_device_khci.h usb_device_dci.c usb_device_dci.h usb_device_ch9.c usb_device_ch9.h
  group usb/device/class
    ../../../../../middleware/usb/device/class/: usb_device_class.c usb_device_class.h usb_device_cdc_acm.c usb_device_cdc_acm.h
  group freemaster/src/common
    ../../../../../middleware/freemaster/src/common/: freemaster.h freemaster_appcmd.c freemaster_defcfg.h freemaster_pipes.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_tsa.c freemaster_tsa.h freemaster_ures.c freemaster_ures.h freemaster_utils.c freemaster_utils.h freemaster_can.c freemaster_can.h freemaster_sha.c freemaster_pdbdm.c freemaster_serial.c freemaster_serial.h freemaster_net.c freemaster_net.h
  group freemaster/src/platforms/gen32le
    ../../../../../middleware/freemaster/src/platforms/gen32le/: freemaster_gen32le.h
  group freemaster/src/drivers/mcuxsdk/can
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/can/: freemaster_flexcan.c freemaster_flexcan.h freemaster_mscan.c freemaster_mscan.h freemaster_mcan.c freemaster_mcan.h
  group freemaster/src/drivers/mcuxsdk/serial
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/serial/: freemaster_serial_uart.c freemaster_serial_uart.h freemaster_serial_lpsci.c freemaster_serial_lpsci.h freemaster_serial_lpuart.c freemaster_serial_lpuart.h freemaster_serial_usart.c freemaster_serial_usart.h freemaster_serial_miniusart.c freemaster_serial_miniusart.h freemaster_serial_usb.c freemaster_serial_usb.h
  group freemaster/src/drivers/mcuxsdk/network
    ../../../../../middleware/freemaster/src/drivers/mcuxsdk/network/: freemaster_net_segger_rtt.c freemaster_net_segger_rtt.h freemaster_net_lwip_udp.c freemaster_net_lwip_udp.h freemaster_net_lwip_tcp.c freemaster_net_lwip_tcp.h
  group doc
    ../: readme.md example_board_readme.md
