# Keil uVision project dev_printer_virtual_plain_text_freertos.uvprojx, settings and files
target dev_printer_virtual_plain_text_freertos debug (6180000::V6.18::ARMCLANG)
  device: MCXA153VLH NXP
  pack: NXP.MCXA153_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33")
  output: dev_printer_virtual_plain_text_freertos.out
  AfterMake: fromelf.exe --output "$Ldev_printer_virtual_plain_text_freertos.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, USB_STACK_FREERTOS, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MCXA153VLH, OSA_USED, USE_RTOS=1, SDK_OS_FREE_RTOS
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../../../devices/MCXA153/drivers;../../../../../../CMSIS/Core/Include;../../../../../../CMSIS/Core/Include/m-profile;../../../../../../devices/MCXA153;../../../../../../devices/MCXA153/periph;../../../../../../devices/MCXA153/utilities/debug_console_lite;../../../../../../components/lists;../../../../../../devices/MCXA153/utilities/str;../../../../../../components/uart;../../../../../../components/osa;../../../../../../middleware/usb/include;../../../../../../middleware/usb/device;../../../../../../middleware/usb/device/class;../../../../../../rtos/freertos/freertos-kernel/include;../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure;../../../../../../rtos/freertos/freertos-kernel/template
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL, MCUXPRESSO_SDK, CPU_MCXA153VLH, OSA_USED
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT6: RAM 0x4000000 size 0x2000
  memory RVCT7: RAM 0x14000000 size 0x2000
  memory RVCT8: RAM 0x4002000 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MCXA153_flash.scf
  link misc: --remove --predefine=\"-D__heap_size__=0x100\" --predefine=\"-D__stack_size__=0x1000\" --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: device_printer.c device_printer.h usb_device_descriptor.c usb_device_descriptor.h hardware_init.c pin_mux.c pin_mux.h FreeRTOSConfig_Gen.h fsl_os_abstraction_config.h mcux_config.h usb_device_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c
  group drivers
    ../../../../../../devices/MCXA153/drivers/: fsl_clock.c fsl_clock.h fsl_inputmux_connections.h fsl_reset.c fsl_reset.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_spc.h fsl_spc.c fsl_port.h
  group CMSIS
    ../../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv8m_mpu.h
  group device
    ../../../../../../devices/MCXA153/: fsl_device_registers.h MCXA153.h MCXA153_features.h MCXA153_COMMON.h system_MCXA153.c system_MCXA153.h
  group device/periph
    ../../../../../../devices/MCXA153/periph/: PERI_ADC.h PERI_AOI.h PERI_CDOG.h PERI_CMC.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUGMAILBOX.h PERI_DMA.h PERI_EIM.h PERI_EQDC.h PERI_ERM.h PERI_FMC.h PERI_FMU.h PERI_FMUTEST.h PERI_FREQME.h PERI_GLIKEY.h PERI_GPIO.h PERI_I3C.h PERI_INPUTMUX.h PERI_LPCMP.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPTMR.h PERI_LPUART.h PERI_MRCC.h PERI_OSTIMER.h PERI_PORT.h PERI_PWM.h PERI_SCG.h PERI_SPC.h PERI_SYSCON.h PERI_TRDC.h PERI_USB.h PERI_UTICK.h PERI_VBAT.h PERI_WAKETIMER.h PERI_WUU.h PERI_WWDT.h
  group startup/arm
    ../../../../../../devices/MCXA153/arm/: startup_MCXA153.S
  group utilities
    ../../../../../../devices/MCXA153/utilities/debug_console_lite/: fsl_assert.h fsl_assert.c
    ../../../../../../devices/MCXA153/utilities/: fsl_memcpy.S
  group component/lists
    ../../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group utilities/str
    ../../../../../../devices/MCXA153/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console_lite
    ../../../../../../devices/MCXA153/utilities/debug_console_lite/: fsl_debug_console.h fsl_debug_console.c
  group component/uart
    ../../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group component/osa
    ../../../../../../components/osa/: fsl_os_abstraction.h fsl_os_abstraction_free_rtos.h fsl_os_abstraction_free_rtos.c
  group usb/include
    ../../../../../../middleware/usb/include/: usb.h usb_misc.h usb_spec.h
  group usb/device
    ../../../../../../middleware/usb/device/: usb_device.h usb_device_khci.c usb_device_khci.h usb_device_dci.c usb_device_dci.h usb_device_ch9.c usb_device_ch9.h
  group usb/device/class
    ../../../../../../middleware/usb/device/class/: usb_device_class.c usb_device_class.h usb_device_printer.c usb_device_printer.h
  group freertos/freertos-kernel
    ../../../../../../rtos/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../../../../../../rtos/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stdint.readme stream_buffer.h task.h timers.h
  group freertos/freertos-kernel/portable/MemMang
    ../../../../../../rtos/freertos/freertos-kernel/portable/MemMang/: ReadMe.url heap_4.c
  group freertos/freertos-kernel/portable
    ../../../../../../rtos/freertos/freertos-kernel/portable/: readme.txt
  group freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure
    ../../../../../../rtos/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.c port.c portasm.c portasm.h portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/template
    ../../../../../../rtos/freertos/freertos-kernel/template/: FreeRTOSConfig.h
  group doc
    ../: readme.md device_printer_add_printer_1.jpg device_printer_add_printer_2.jpg device_printer_dev&printer.jpg device_printer_devmgmt.jpg device_printer_devmgmt_install1.jpg device_printer_devmgmt_win10.jpg device_printer_example_text.jpg device_printer_example_text_output.jpg device_printer_find_port.jpg device_printer_install_driver_auto.jpg
target dev_printer_virtual_plain_text_freertos release (6130001::V6.13.1::.\ARMCLANG)
  device: MCXA153VLH NXP
  pack: NXP.MCXA153_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33")
  output: dev_printer_virtual_plain_text_freertos.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, USB_STACK_FREERTOS, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MCXA153VLH, OSA_USED, USE_RTOS=1, SDK_OS_FREE_RTOS
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL, MCUXPRESSO_SDK, CPU_MCXA153VLH, OSA_USED
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT6: RAM 0x4000000 size 0x2000
  memory RVCT7: RAM 0x14000000 size 0x2000
  memory RVCT8: RAM 0x4002000 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MCXA153_flash.scf
  link misc: as above
