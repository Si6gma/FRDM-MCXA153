# Keil uVision project se05x_ex_symmetric.uvprojx, settings and files
target se05x_ex_symmetric debug (6180000::V6.18::ARMCLANG)
  device: MCXA153VLH NXP
  pack: NXP.MCXA153_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33")
  output: se05x_ex_symmetric.out
  AfterMake: fromelf.exe --output "$Lse05x_ex_symmetric.bin" --bincombined "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, SIMW_DEMO_ENABLE__DEMO_EX_SYMMETRIC, SDK_DEBUGCONSOLE_UART, MCXA, AX_EMBEDDED, PRINTF_ADVANCED_ENABLE=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MCXA153VLH, SERIAL_PORT_TYPE_UART=1, T1oI2C, T1oI2C_UM11225, SSS_USE_FTR_FILE, NO_SECURE_CHANNEL_SUPPORT, SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC
  c misc: -include ../mcux_config.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../../../devices/MCXA153/drivers;../../../../../CMSIS/Core/Include;../../../../../CMSIS/Core/Include/m-profile;../../../../../devices/MCXA153;../../../../../devices/MCXA153/periph;../../../../../devices/MCXA153/utilities;../../../../../components/lists;../../../../../devices/MCXA153/utilities/str;../../../../../devices/MCXA153/utilities/debug_console;../../../../../components/serial_manager;../../../../../components/uart;../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/log;../../../../../middleware/se_hostlib/hostlib/hostLib/platform/inc;../../../../../middleware/se_hostlib/hostlib/hostLib/platform/ksdk;../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom;../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/T1oI2C;../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/infra;../../../../../middleware/se_hostlib/sss/ex/inc;../../../../../middleware/se_hostlib/sss/ex/src;../../../../../middleware/se_hostlib/hostlib/hostLib/se05x_03_xx_xx;../../../../../middleware/se_hostlib/sss/port/ksdk;../../../../../middleware/se_hostlib/hostlib/hostLib/inc;../../../../../middleware/se_hostlib/hostlib/hostLib/se05x/src;../../../../../middleware/se_hostlib/sss/inc;../../../../../middleware/se_hostlib;../../../../../middleware/se_hostlib/platform
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL, MCUXPRESSO_SDK, CPU_MCXA153VLH
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT6: RAM 0x4000000 size 0x2000
  memory RVCT7: RAM 0x14000000 size 0x2000
  memory RVCT8: RAM 0x4002000 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MCXA153_flash.scf
  link misc: --remove --predefine=\"-D__stack_size__=0x2000\" --predefine=\"-D__heap_size__=0x3000\" --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ../: readme.rst se_board_config.c se_board_config.h ex_sss_symmetric.c fsl_sss_ftr.h fsl_debug_console_conf.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h
  group drivers
    ../../../../../devices/MCXA153/drivers/: fsl_clock.c fsl_clock.h fsl_inputmux_connections.h fsl_reset.c fsl_reset.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_gpio.h fsl_gpio.c fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.h fsl_lpuart.c fsl_spc.h fsl_spc.c fsl_port.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../CMSIS/Core/Include/m-profile/: cmsis_armclang_m.h armv8m_mpu.h
  group device
    ../../../../../devices/MCXA153/: fsl_device_registers.h MCXA153.h MCXA153_features.h MCXA153_COMMON.h system_MCXA153.c system_MCXA153.h
  group device/periph
    ../../../../../devices/MCXA153/periph/: PERI_ADC.h PERI_AOI.h PERI_CDOG.h PERI_CMC.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUGMAILBOX.h PERI_DMA.h PERI_EIM.h PERI_EQDC.h PERI_ERM.h PERI_FMC.h PERI_FMU.h PERI_FMUTEST.h PERI_FREQME.h PERI_GLIKEY.h PERI_GPIO.h PERI_I3C.h PERI_INPUTMUX.h PERI_LPCMP.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPTMR.h PERI_LPUART.h PERI_MRCC.h PERI_OSTIMER.h PERI_PORT.h PERI_PWM.h PERI_SCG.h PERI_SPC.h PERI_SYSCON.h PERI_TRDC.h PERI_USB.h PERI_UTICK.h PERI_VBAT.h PERI_WAKETIMER.h PERI_WUU.h PERI_WWDT.h
  group startup/arm
    ../../../../../devices/MCXA153/arm/: startup_MCXA153.S
  group utilities
    ../../../../../devices/MCXA153/utilities/: fsl_assert.h fsl_assert.c fsl_memcpy.S
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group utilities/str
    ../../../../../devices/MCXA153/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console
    ../../../../../devices/MCXA153/utilities/debug_console/: fsl_debug_console.h fsl_debug_console.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group se_hostlib/hostlib/hostLib/libCommon/log
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/log/: nxLog.c nxLog.h nxLog_App.h nxLog_DefaultConfig.h nxLog_UseCases.h nxLog_VCOM.h nxLog_hostLib.h nxLog_mbedtls.h nxLog_scp.h nxLog_smCom.h nxLog_sscp.h nxLog_sss.h
  group se_hostlib/hostlib/hostLib/platform/inc
    ../../../../../middleware/se_hostlib/hostlib/hostLib/platform/inc/: ax_reset.h i2c_a7.h se05x_apis.h se_pit_config.h se_reset_config.h sm_printf.h sm_timer.h
  group se_hostlib/hostlib/hostLib/platform/ksdk
    ../../../../../middleware/se_hostlib/hostlib/hostLib/platform/ksdk/: ax_reset.c i2c_frdm.c i2c_imxrt.c i2c_mcxa.c i2c_mcxn9.c i2c_lpc54xxx.c i2c_lpc55sxx.c se05x_reset.c timer_kinetis.c timer_kinetis_bm.c timer_kinetis_freertos.c timer_kinetis_threadx.c
  group se_hostlib/hostlib/hostLib/libCommon/smCom
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/: apduComm.h sci2c_cfg.h smCom.c smCom.h smComT1oI2C.c smComT1oI2C.h
  group se_hostlib/hostlib/hostLib/libCommon/smCom/T1oI2C
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/smCom/T1oI2C/: phEseStatus.h phEseTypes.h phNxpEsePal_i2c.h phNxpEseProto7816_3.h phNxpEse_Api.h phNxpEse_Internal.h phNxpEsePal_i2c.c phNxpEseProto7816_3.c phNxpEse_Api.c
  group se_hostlib/hostlib/hostLib/libCommon/infra
    ../../../../../middleware/se_hostlib/hostlib/hostLib/libCommon/infra/: global_platf.c sm_connect.c app_boot.h app_boot_nfc.h cm_commands.h global_platf.h sm_apdu.h sm_api.h sm_demo_utils.h sm_errors.h sm_types.h sm_apdu.c sm_errors.c sm_printf.c
  group se_hostlib/sss/ex/inc
    ../../../../../middleware/se_hostlib/sss/ex/inc/: ex_scp03_puf.h ex_sss.h ex_sss_auth.h ex_sss_boot.h ex_sss_main_cc_inc.h ex_sss_main_freeRTOS_inc.h ex_sss_main_inc.h ex_sss_main_inc_frdmk64f.h ex_sss_main_inc_imx_rt.h ex_sss_main_inc_ksdk.h ex_sss_main_inc_linux.h ex_sss_main_inc_lpcxpresso55s.h ex_sss_main_inc_mcxa153.h ex_sss_main_inc_mcxn9.h ex_sss_main_inc_mpc5748g.h ex_sss_main_inc_nrf.h ex_sss_main_inc_qn9090.h ex_sss_objid.h ex_sss_ports.h ex_sss_scp03_keys.h ex_sss_tp_scp03_keys.h
  group se_hostlib/sss/ex/src
    ../../../../../middleware/se_hostlib/sss/ex/src/: ex_sss_boot.c ex_sss_boot_connectstring.c ex_sss_boot_int.h ex_sss_se05x.c ex_sss_se05x_auth.c
  group se_hostlib/hostlib/hostLib/se05x_03_xx_xx
    ../../../../../middleware/se_hostlib/hostlib/hostLib/se05x_03_xx_xx/: se05x_APDU.c se05x_APDU.h se05x_APDU_apis.h se05x_APDU_impl.h se05x_04_xx_APDU_apis.h se05x_04_xx_APDU_impl.h
  group se_hostlib
    ../../../../../middleware/se_hostlib/: ChangeLogKSDK.txt
  group se_hostlib/sss/port/ksdk
    ../../../../../middleware/se_hostlib/sss/port/ksdk/: fsl_sss_types.h
  group se_hostlib/hostlib/hostLib/inc
    ../../../../../middleware/se_hostlib/hostlib/hostLib/inc/: Applet_SE050_Ver.h PlugAndTrust_HostLib_Ver.h PlugAndTrust_Pkg_Ver.h SE_HAL_Lib.h ax_api.h ax_common.h ax_common_private.h ax_scp.h ax_scp_private.h ax_sss_scp.h ax_util.h ledHandler.h modules.h nxEnsure.h nxScp03_Apis.h nxScp03_Const.h nxScp03_Types.h scp.h se05x_const.h se05x_ecc_curves.h se05x_ecc_curves_inc.h se05x_ecc_curves_values.h se05x_enums.h se05x_ftr.h se05x_tlv.h sm_const.h
  group se_hostlib/hostlib/hostLib/se05x/src
    ../../../../../middleware/se_hostlib/hostlib/hostLib/se05x/src/: se05x_ECC_curves.c se05x_mw.c se05x_tlv.c
  group se_hostlib/sss/inc
    ../../../../../middleware/se_hostlib/sss/inc/: fsl_sss_api.h fsl_sss_api_ver.h fsl_sss_config.h fsl_sss_ftr_default.h fsl_sss_keyid_map.h fsl_sss_lpc55s_apis.h fsl_sss_lpc55s_types.h fsl_sss_mbedtls_apis.h fsl_sss_mbedtls_types.h fsl_sss_openssl_apis.h fsl_sss_openssl_types.h fsl_sss_policy.h fsl_sss_se05x_apis.h fsl_sss_se05x_policy.h fsl_sss_se05x_scp03.h fsl_sss_se05x_types.h fsl_sss_user_apis.h fsl_sss_user_types.h fsl_sss_util_asn1_der.h fsl_sss_util_rsa_sign_utils.h
  group se_hostlib/sss/src
    ../../../../../middleware/se_hostlib/sss/src/: fsl_sss_apis.c fsl_sss_util_asn1_der.c fsl_sss_util_rsa_sign_utils.c
  group se_hostlib/sss/src/se05x
    ../../../../../middleware/se_hostlib/sss/src/se05x/: fsl_sss_se05x_apis.c fsl_sss_se05x_eckey.c fsl_sss_se05x_mw.c fsl_sss_se05x_policy.c fsl_sss_se05x_scp03.c
  group doc
    ../: readme.md example_board_readme.md
target se05x_ex_symmetric release (6130001::V6.13.1::.\ARMCLANG)
  device: MCXA153VLH NXP
  pack: NXP.MCXA153_DFP.17.0.0
  cpu: CPUTYPE("Cortex-M33")
  output: se05x_ex_symmetric.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, SIMW_DEMO_ENABLE__DEMO_EX_SYMMETRIC, SDK_DEBUGCONSOLE_UART, MCXA, AX_EMBEDDED, PRINTF_ADVANCED_ENABLE=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MCXA153VLH, SERIAL_PORT_TYPE_UART=1, T1oI2C, T1oI2C_UM11225, SSS_USE_FTR_FILE, NO_SECURE_CHANNEL_SUPPORT, SCP_MODE=C_MAC_C_ENC_R_MAC_R_ENC
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL, MCUXPRESSO_SDK, CPU_MCXA153VLH
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x20000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT6: RAM 0x4000000 size 0x2000
  memory RVCT7: RAM 0x14000000 size 0x2000
  memory RVCT8: RAM 0x4002000 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: MCXA153_flash.scf
  link misc: as above
