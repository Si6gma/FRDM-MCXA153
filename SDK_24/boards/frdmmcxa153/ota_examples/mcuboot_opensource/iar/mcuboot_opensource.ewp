# IAR project mcuboot_opensource.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXA153 NXP MCXA153
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; PRINTF_ADVANCED_ENABLE=1; SHELL_PRINT_COPYRIGHT=0; MBEDTLS_USER_CONFIG_FILE="mbedtls_user_config.h"; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MCXA153VLH; SERIAL_PORT_TYPE_UART=1; MFLASH_FILE_BASEADDR=122880
  ICCARM.IExtraOptions: --diag_suppress=Pe550  --diag_suppress=Pe257,Pa039  --diag_suppress=Pa082,Pa050 --diag_suppress=Pa082,Pa050
  ICCARM.PreInclude: ../mcux_config.h
  ICCARM.CCIncludePath2: ..; ../../../../../devices/MCXA153/drivers; ../../../../../CMSIS/Core/Include; ../../../../../CMSIS/Core/Include/m-profile; ../../../../../devices/MCXA153; ../../../../../devices/MCXA153/periph; ../../../../../devices/MCXA153/utilities; ../../../../../components/lists; ../../../../../devices/MCXA153/utilities/str; ../../../../../devices/MCXA153/utilities/debug_console; ../../../../../components/serial_manager; ../../../../../components/uart; ../../../../../components/flash/mflash; ../../../../../components/flash/mflash/mcxa; ../../../../../middleware/mcuboot_opensource/boot/bootutil/src; ../../../../../middleware/mcuboot_opensource/boot/bootutil/include; ../../../../../middleware/mcuboot_opensource/ext/tinycrypt/lib/include; ../../../../../middleware/mcuboot_opensource/ext/mbedtls-asn1/include; ../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/flashapi; ../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/keys; ../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/include; ../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/include/mcuboot_config; ../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: MCUXPRESSO_SDK; CPU_MCXA153VLH
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: mcuboot_opensource.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x400
  ILINK.IlinkIcfFile: MCXA153_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; PRINTF_ADVANCED_ENABLE=1; SHELL_PRINT_COPYRIGHT=0; MBEDTLS_USER_CONFIG_FILE="mbedtls_user_config.h"; SDK_DEBUGCONSOLE=1; MCUX_META_BUILD; MCUXPRESSO_SDK; CPU_MCXA153VLH; SERIAL_PORT_TYPE_UART=1; MFLASH_FILE_BASEADDR=122880
  ICCARM.CCOptLevel: 3
  group source
    ../: main.c sblconfig.h flash_partitioning.h flash_partitioning.c mbedtls_user_config.h fsl_debug_console_conf.h mcux_config.h
  group board
    ../: board.h board.c clock_config.h clock_config.c pin_mux.c pin_mux.h
  group drivers
    ../../../../../devices/MCXA153/drivers/: fsl_romapi.h fsl_clock.c fsl_clock.h fsl_inputmux_connections.h fsl_reset.c fsl_reset.h fsl_common.h fsl_common.c fsl_common_arm.c fsl_common_arm.h fsl_glikey.h fsl_glikey.c fsl_gpio.h fsl_gpio.c fsl_lpuart.h fsl_lpuart.c fsl_spc.h fsl_spc.c fsl_port.h
  group CMSIS
    ../../../../../CMSIS/Core/Include/: cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    ../../../../../CMSIS/Core/Include/m-profile/: cmsis_iccarm_m.h armv8m_mpu.h
  group device
    ../../../../../devices/MCXA153/: fsl_device_registers.h MCXA153.h MCXA153_features.h MCXA153_COMMON.h system_MCXA153.c system_MCXA153.h
  group device/periph
    ../../../../../devices/MCXA153/periph/: PERI_ADC.h PERI_AOI.h PERI_CDOG.h PERI_CMC.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUGMAILBOX.h PERI_DMA.h PERI_EIM.h PERI_EQDC.h PERI_ERM.h PERI_FMC.h PERI_FMU.h PERI_FMUTEST.h PERI_FREQME.h PERI_GLIKEY.h PERI_GPIO.h PERI_I3C.h PERI_INPUTMUX.h PERI_LPCMP.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPTMR.h PERI_LPUART.h PERI_MRCC.h PERI_OSTIMER.h PERI_PORT.h PERI_PWM.h PERI_SCG.h PERI_SPC.h PERI_SYSCON.h PERI_TRDC.h PERI_USB.h PERI_UTICK.h PERI_VBAT.h PERI_WAKETIMER.h PERI_WUU.h PERI_WWDT.h
  group startup/iar
    ../../../../../devices/MCXA153/iar/: startup_MCXA153.s
  group utilities
    ../../../../../devices/MCXA153/utilities/: fsl_assert.h fsl_assert.c
  group utilities/str
    ../../../../../devices/MCXA153/utilities/str/: fsl_str.h fsl_str.c
  group utilities/debug_console
    ../../../../../devices/MCXA153/utilities/debug_console/: fsl_debug_console.h fsl_debug_console.c
  group component/lists
    ../../../../../components/lists/: fsl_component_generic_list.h fsl_component_generic_list.c
  group component/serial_manager
    ../../../../../components/serial_manager/: fsl_component_serial_manager.h fsl_component_serial_port_internal.h fsl_component_serial_manager.c fsl_component_serial_port_uart.h fsl_component_serial_port_uart.c
  group component/uart
    ../../../../../components/uart/: fsl_adapter_uart.h fsl_adapter_lpuart.c
  group flash/mflash
    ../../../../../components/flash/mflash/: mflash_common.h mflash_file.c mflash_file.h
  group flash/mflash/mcxa
    ../../../../../components/flash/mflash/mcxa/: mflash_drv.c mflash_drv.h
  group bootutil/include/bootutil
    ../../../../../middleware/mcuboot_opensource/boot/bootutil/include/bootutil/: bench.h boot_hooks.h boot_public_hooks.h boot_record.h boot_status.h bootutil.h bootutil_log.h bootutil_public.h bootutil_test.h caps.h enc_key.h enc_key_public.h fault_injection_hardening.h fault_injection_hardening_delay_rng.h ignore.h image.h mcuboot_status.h ramload.h security_cnt.h sign_key.h
  group bootutil/include/bootutil/crypto
    ../../../../../middleware/mcuboot_opensource/boot/bootutil/include/bootutil/crypto/: aes_ctr.h aes_kw.h common.h ecdh_p256.h ecdh_x25519.h ecdsa.h hmac_sha256.h rsa.h sha.h
  group bootutil/src
    ../../../../../middleware/mcuboot_opensource/boot/bootutil/src/: boot_record.c bootutil_misc.c bootutil_misc.h bootutil_priv.h bootutil_public.c caps.c encrypted.c fault_injection_hardening.c fault_injection_hardening_delay_rng_mbedtls.c image_ecdsa.c image_ed25519.c image_rsa.c image_validate.c loader.c swap_misc.c swap_move.c swap_priv.h swap_scratch.c tlv.c
  group bootutil/nxp_port
    ../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/: boot.c boot.h bootutil_hooks.c keys.c
  group bootutil/nxp_port/include
    ../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/include/: flash_map.h
  group bootutil/nxp_port/include/flash_map_backend
    ../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/include/flash_map_backend/: flash_map_backend.h
  group bootutil/nxp_port/include/mcuboot_config
    ../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/include/mcuboot_config/: mcuboot_config.h mcuboot_logging.h
  group bootutil/nxp_port/include/os
    ../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/include/os/: os_malloc.h
  group bootutil/nxp_port/include/sysflash
    ../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/include/sysflash/: sysflash.h
  group bootutil/flashapi
    ../../../../../middleware/mcuboot_opensource/boot/nxp_mcux_sdk/flashapi/: flash_api_mcxn10.c
  group tinycrypt/include/tinycrypt
    ../../../../../middleware/mcuboot_opensource/ext/tinycrypt/lib/include/tinycrypt/: aes.h cbc_mode.h ccm_mode.h cmac_mode.h constants.h ctr_mode.h ctr_prng.h ecc.h ecc_dsa.h hmac.h hmac_prng.h sha256.h utils.h ecc_platform_specific.h
  group tinycrypt/source
    ../../../../../middleware/mcuboot_opensource/ext/tinycrypt/lib/source/: aes_decrypt.c aes_encrypt.c cbc_mode.c ccm_mode.c cmac_mode.c ctr_mode.c ctr_prng.c ecc.c ecc_dsa.c hmac.c hmac_prng.c sha256.c utils.c
  group mbedtls-asn1/include
    ../../../../../middleware/mcuboot_opensource/ext/mbedtls-asn1/include/: common.h
  group mbedtls-asn1/include/mbedtls
    ../../../../../middleware/mcuboot_opensource/ext/mbedtls-asn1/include/mbedtls/: asn1.h bignum.h build_info.h check_config.h ecdsa.h ecp.h error.h mbedtls_config.h md.h oid.h pk.h platform.h platform_util.h private_access.h rsa.h threading.h version.h
  group mbedtls-asn1/src
    ../../../../../middleware/mcuboot_opensource/ext/mbedtls-asn1/src/: asn1parse.c platform_util.c
  group doc
    ../: readme.md example_board_readme.md
